# Keil uVision project XYD_Watch.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XYD_Watch +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F411xE
  c include: .\CMSIS;.\USER\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group USER
    ./USER/src/: main.c key.c led.c exti.c delay.c uart.c timer.c oled.c spi.c iic.c sht20.c hp6.c mpu6050.c rtc.c motor.c
    ./USER/inc/: hp6.h mpu6050.h rtc.h ui.h motor.h
